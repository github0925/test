FILES_${PN} += "${datadir}/cmake/OEToolchainConfig.cmake.d/"