FILESEXTRAPATHS_prepend := "${THISDIR}/alsapatchs:"
SRC_URI += "file://0001-sd-modify-alsa-lib.patch"
