FILESEXTRAPATHS_prepend := "${THISDIR}/patch:"

SRC_URI_append := " file://0001-mini-x-session-fix-always-fullscreen-issue.patch"
