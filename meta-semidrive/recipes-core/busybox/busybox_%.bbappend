SRC_URI += "file://fragment.cfg;subdir=busybox-1.27.2"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

