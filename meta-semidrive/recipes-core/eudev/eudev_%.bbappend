SRC_URI += "file://change-poll-timeout-from-1s-to-20ms.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

