# IAR project safety-x9e-ref_ddram.ewp, settings and files
configuration safety-x9e-ref_ddram (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.PreInclude: iar_config.h
  ICCARM.CCIncludePath2: ..\..\..\.\build-safety-x9e-ref; ..\..\..\.\include; ..\..\..\.\include\kernel; ..\..\..\.\include\shared; ..\..\..\.\include\shared\lk; ..\..\..\.\include\uapi; ..\..\..\.\include\uapi\uapi; ..\..\..\3rd\fatfs\src\include; ..\..\..\3rd\littlevgl; ..\..\..\3rd\littlevgl\include; ..\..\..\3rd\littlevgl\lvgl-release-v7; ..\..\..\3rd\rpmsg-lite\include; ..\..\..\application\early_app\BootAnimation\inc; ..\..\..\application\early_app\BootAnimation\include; ..\..\..\application\early_app\cluster; ..\..\..\application\early_app\cluster\..\..\..\include\dev\; ..\..\..\application\early_app\cluster\..\..\..\lib\sd_graphics\inc; ..\..\..\application\early_app\cluster\inc; ..\..\..\application\early_app\cluster\include; ..\..\..\application\early_app\include; ..\..\..\application\early_app\main\inc; ..\..\..\application\early_app\main\include; ..\..\..\application\services\update_monitor\include; ..\..\..\application\system\boot_ss\include; ..\..\..\application\system\kernel_monitor\include; ..\..\..\application\system\ospi_handover\include; ..\..\..\application\system\pvt\include; ..\..\..\application\test\g2dlite\include; ..\..\..\application\tools\port_helper\include; ..\..\..\application\tools\sem_monitor\include; ..\..\..\arch\arm\arm\include; ..\..\..\arch\arm\include; ..\..\..\chipcfg\generate\x9_eco\chip\; ..\..\..\chipcfg\generate\x9_eco\projects\serdes\; ..\..\..\chipcfg\generate\x9_eco\projects\serdes\safety; ..\..\..\chipcfg\generate\x9_eco\targets\reference_x9\; ..\..\..\chipcfg\generate\x9_eco\targets\reference_x9\safety; ..\..\..\chipdev\clkgen\sd_clkgen\inc\; ..\..\..\chipdev\clkgen\sd_clkgen\include; ..\..\..\chipdev\crypto\silex\include; ..\..\..\chipdev\crypto\silex\include\; ..\..\..\chipdev\csi\sd_csi\include; ..\..\..\chipdev\csi\sd_csi\include\; ..\..\..\chipdev\dio\sd_dio\inc\; ..\..\..\chipdev\dio\sd_dio\include; ..\..\..\chipdev\dma\dw_dma1\include; ..\..\..\chipdev\dma\dw_dma1\include\; ..\..\..\chipdev\func_safety\inc\; ..\..\..\chipdev\func_safety\include; ..\..\..\chipdev\fuse_ctrl\inc\; ..\..\..\chipdev\fuse_ctrl\include; ..\..\..\chipdev\i2c\dw_i2c\include; ..\..\..\chipdev\i2c\dw_i2c\include\; ..\..\..\chipdev\i2s\cadence_i2s\..\..\..\hal\audio_hal\common; ..\..\..\chipdev\i2s\cadence_i2s\2.0\inc\; ..\..\..\chipdev\i2s\cadence_i2s\2.0\include; ..\..\..\chipdev\interrupt\arm_gic\inc\; ..\..\..\chipdev\interrupt\arm_gic\include; ..\..\..\chipdev\mailbox\sd_mbox; ..\..\..\chipdev\mailbox\sd_mbox\include; ..\..\..\chipdev\pll\inc; ..\..\..\chipdev\pll\include; ..\..\..\chipdev\pmu\sd_pmu\inc\; ..\..\..\chipdev\pmu\sd_pmu\include; ..\..\..\chipdev\port\sd_port\inc\; ..\..\..\chipdev\port\sd_port\include; ..\..\..\chipdev\pwm\sd_pwm\inc\; ..\..\..\chipdev\pwm\sd_pwm\include; ..\..\..\chipdev\rstgen\sd_rstgen\inc\; ..\..\..\chipdev\rstgen\sd_rstgen\include; ..\..\..\chipdev\rtc\inc\; ..\..\..\chipdev\rtc\include; ..\..\..\chipdev\scr\include; ..\..\..\chipdev\spi_nor; ..\..\..\chipdev\spi_nor\device; ..\..\..\chipdev\spi_nor\host; ..\..\..\chipdev\spi_nor\include; ..\..\..\chipdev\timer\sd_timer\inc\; ..\..\..\chipdev\timer\sd_timer\include; ..\..\..\chipdev\uart\dw_uart\inc\; ..\..\..\chipdev\uart\dw_uart\include; ..\..\..\chipdev\vpu\codaj12\inc; ..\..\..\chipdev\vpu\codaj12\inc\jdi; ..\..\..\chipdev\vpu\codaj12\inc\jpuapi; ..\..\..\chipdev\vpu\codaj12\include; ..\..\..\exdev\am_board\..\..\..\..\hal\audio_hal\common; ..\..\..\exdev\am_board\include; ..\..\..\exdev\am_board\refa04\inc\; ..\..\..\exdev\am_codec\..\..\..\..\hal\audio_hal\common; ..\..\..\exdev\am_codec\ak7738\inc\; ..\..\..\exdev\am_codec\include; ..\..\..\exdev\am_codec\tas5404\inc\; ..\..\..\exdev\am_codec\tas6424\inc\; ..\..\..\exdev\am_codec\tca9539\inc\; ..\..\..\exdev\am_codec\xf6020\inc\; ..\..\..\exdev\audio_codec\ak7738\..\..\..\..\hal\audio_hal\common; ..\..\..\exdev\audio_codec\ak7738\inc\; ..\..\..\exdev\audio_codec\ak7738\include; ..\..\..\exdev\audio_codec\tas6424\..\..\..\..\hal\audio_hal\common; ..\..\..\exdev\audio_codec\tas6424\inc\; ..\..\..\exdev\audio_codec\tas6424\include; ..\..\..\exdev\camera\include; ..\..\..\exdev\display\include; ..\..\..\exdev\display\lv_drivers\decoder\lodepng; ..\..\..\exdev\display\lv_drivers\decoder\sjpg; ..\..\..\exdev\display\lv_drivers\gpu; ..\..\..\exdev\gpio\include; ..\..\..\exdev\lcm; ..\..\..\exdev\lcm\ds90ub9xx\include; ..\..\..\exdev\lcm\include; ..\..\..\exdev\lcm\lvds_hsd123_serdes_1920x720_lcd\include; ..\..\..\exdev\lcm\sn65dsi85\include; ..\..\..\exdev\norflash; ..\..\..\exdev\norflash\include; ..\..\..\exdev\touch\include; ..\..\..\external\include; ..\..\..\external\include\shared; ..\..\..\external\include\shared\lk; ..\..\..\external\include\uapi; ..\..\..\external\include\uapi\uapi; ..\..\..\framework\communication\include; ..\..\..\framework\lib\mem_image; ..\..\..\framework\lib\mem_image\include; ..\..\..\framework\protocol\include; ..\..\..\framework\protocol\include\; ..\..\..\framework\rpbuf\include; ..\..\..\framework\rpbuf\include\; ..\..\..\framework\service\audio\include; ..\..\..\framework\service\backlight\backlight_rtos\include; ..\..\..\framework\service\base; ..\..\..\framework\service\base\include; ..\..\..\framework\service\camera\include; ..\..\..\framework\service\input\include; ..\..\..\framework\service\property; ..\..\..\framework\service\property\include; ..\..\..\framework\service\rpmsg\include; ..\..\..\framework\service\sys_diagnosis; ..\..\..\framework\service\sys_diagnosis\include; ..\..\..\framework\service\worker; ..\..\..\framework\service\worker\include; ..\..\..\framework\test\dcf\include; ..\..\..\hal\audio_hal\audio_manager\inc\; ..\..\..\hal\audio_hal\audio_manager\include; ..\..\..\hal\audio_hal\audio_manager\lib\inc; ..\..\..\hal\boardinfo\; ..\..\..\hal\boardinfo\include; ..\..\..\hal\clkgen_hal\sd_clkgen_hal\inc\; ..\..\..\hal\clkgen_hal\sd_clkgen_hal\include; ..\..\..\hal\cpu_hal\sd_cpu_hal\inc; ..\..\..\hal\cpu_hal\sd_cpu_hal\include; ..\..\..\hal\crypto_hal\inc\; ..\..\..\hal\crypto_hal\include; ..\..\..\hal\csi_hal\sd_csi_hal\inc\; ..\..\..\hal\csi_hal\sd_csi_hal\include; ..\..\..\hal\dio_hal\sd_dio_hal\inc\; ..\..\..\hal\dio_hal\sd_dio_hal\include; ..\..\..\hal\disp_hal\sd_disp_hal\inc; ..\..\..\hal\disp_hal\sd_disp_hal\include; ..\..\..\hal\disp_hal\sd_disp_hal\lib\inc; ..\..\..\hal\dma_hal\sd_dma_hal\inc\; ..\..\..\hal\dma_hal\sd_dma_hal\include; ..\..\..\hal\firewall_hal\inc\; ..\..\..\hal\firewall_hal\include; ..\..\..\hal\g2dlite_hal\sd_g2dlite_hal\inc\; ..\..\..\hal\g2dlite_hal\sd_g2dlite_hal\include; ..\..\..\hal\g2dlite_hal\sd_g2dlite_hal\lib\inc; ..\..\..\hal\gpioirq_hal\include; ..\..\..\hal\gpioirq_hal\include\; ..\..\..\hal\i2c_hal\sd_i2c_hal\inc\; ..\..\..\hal\i2c_hal\sd_i2c_hal\include; ..\..\..\hal\i2s_hal\sd_i2s_hal\2.0\inc\; ..\..\..\hal\i2s_hal\sd_i2s_hal\2.0\include; ..\..\..\hal\i2s_hal\sd_i2s_hal\inc\; ..\..\..\hal\include\; ..\..\..\hal\interrupt_hal\arm_gic_hal\inc\; ..\..\..\hal\interrupt_hal\arm_gic_hal\include; ..\..\..\hal\mbox_hal\sd_mbox_hal\inc\; ..\..\..\hal\mbox_hal\sd_mbox_hal\include; ..\..\..\hal\mmc\inc\; ..\..\..\hal\mmc\include; ..\..\..\hal\module_helper_hal\inc; ..\..\..\hal\module_helper_hal\include; ..\..\..\hal\net\include; ..\..\..\hal\pll\inc; ..\..\..\hal\pll\include; ..\..\..\hal\pmu_hal\sd_pmu_hal\inc\; ..\..\..\hal\pmu_hal\sd_pmu_hal\include; ..\..\..\hal\port_hal\sd_port_hal\inc\; ..\..\..\hal\port_hal\sd_port_hal\include; ..\..\..\hal\pvt_hal\inc\; ..\..\..\hal\pvt_hal\include; ..\..\..\hal\pwm_hal\sd_pwm_hal\inc\; ..\..\..\hal\pwm_hal\sd_pwm_hal\include; ..\..\..\hal\res\inc; ..\..\..\hal\res\include; ..\..\..\hal\rstgen_hal\sd_rstgen_hal\inc\; ..\..\..\hal\rstgen_hal\sd_rstgen_hal\include; ..\..\..\hal\scr\inc; ..\..\..\hal\scr\include; ..\..\..\hal\spdif_hal\sd_spdif_hal\inc\; ..\..\..\hal\spdif_hal\sd_spdif_hal\include; ..\..\..\hal\spi_hal\sd_spi_hal\inc\; ..\..\..\hal\spi_hal\sd_spi_hal\include; ..\..\..\hal\spi_nor\inc\; ..\..\..\hal\spi_nor\include; ..\..\..\hal\timer_hal\sd_timer_hal\inc\; ..\..\..\hal\timer_hal\sd_timer_hal\include; ..\..\..\hal\uart_hal\dw_uart_hal\inc\; ..\..\..\hal\uart_hal\dw_uart_hal\include; ..\..\..\hal\vpu_hal\codaj12\inc\; ..\..\..\hal\vpu_hal\codaj12\include; ..\..\..\hal\wdg_hal\sd_wdg_hal\inc\; ..\..\..\hal\wdg_hal\sd_wdg_hal\include; ..\..\..\include\include; ..\..\..\include\include\shared; ..\..\..\include\include\shared\lk; ..\..\..\include\include\uapi; ..\..\..\include\include\uapi\uapi; ..\..\..\kernel\include; ..\..\..\kernel\lk_wrapper\include; ..\..\..\lib\apploader\include; ..\..\..\lib\boot\include; ..\..\..\lib\cbuf\include; ..\..\..\lib\cbuf\include\lib; ..\..\..\lib\console\include; ..\..\..\lib\container\inc; ..\..\..\lib\container\include; ..\..\..\lib\debug\include; ..\..\..\lib\debugcommands\include; ..\..\..\lib\elf\include; ..\..\..\lib\heap\; ..\..\..\lib\heap\include; ..\..\..\lib\io\include; ..\..\..\lib\libc\include; ..\..\..\lib\reboot; ..\..\..\lib\reboot\include; ..\..\..\lib\res_loader; ..\..\..\lib\res_loader\include; ..\..\..\lib\sdcast\include; ..\..\..\lib\sdrpc; ..\..\..\lib\sdrpc\include; ..\..\..\lib\sdunittest\include; ..\..\..\lib\shell\include; ..\..\..\lib\storage_device\include; ..\..\..\lib\system_config\; ..\..\..\lib\system_config\include; ..\..\..\platform\kunlun; ..\..\..\platform\kunlun\..\..\chipcfg\generate\x9_eco\; ..\..\..\platform\kunlun\common; ..\..\..\platform\kunlun\common\include; ..\..\..\platform\kunlun\safety\; ..\..\..\platform\kunlun\safety\include; ..\..\..\target\reference_x9\safety\; ..\..\..\target\reference_x9\safety\include; ..\..\..\top\include; ..\..\..\lib\sdcast\include; ..\..\..\.; ..\..\..\..\freertos\FreeRTOS\Source\include; ..\..\..\..\freertos\FreeRTOS\Source\portable\GCC\ARM_CR5; ..\..\..\hal\disp_hal\sd_disp_hal\lib\inc; ..\..\..\3rd\rpmsg-lite\include; ..\..\..\exdev\display\lv_drivers\display; ..\..\..\exdev\display\lv_drivers\input; ..\..\..\exdev\display\lv_drivers\fs; ..\..\..\framework\communication\include; ..\..\..\..\..\Source\include; ..\..\..\..\..\Source\portable\GCC\ARM_CR5; ..\..\..\.; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ASSEMBLY; __ICCARM__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: safety-x9e-ref.bin
  ILINK.IlinkOutputFile: safety-x9e-ref.out
  ILINK.IlinkIcfFile: ..\..\..\target\reference_x9\safety\IAR\ddr.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\hal/disp_hal/sd_disp_hal/lib/libdisp_link.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group rpmsg-lite
    ../../../3rd/rpmsg-lite/: llist.c rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c virtqueue.c
    ../../../3rd/rpmsg-lite/porting/: rpmsg_env_lk.c rpmsg_platform.c
  group littlevgl
    ../../../3rd/littlevgl/lvgl-release-v7/src/lv_core/: lv_group.c lv_indev.c lv_disp.c lv_obj.c lv_refr.c lv_style.c
    ../../../3rd/littlevgl/lvgl-release-v7/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../3rd/littlevgl/lvgl-release-v7/src/lv_widgets/: lv_arc.c lv_bar.c lv_checkbox.c lv_cpicker.c lv_dropdown.c lv_keyboard.c lv_line.c lv_msgbox.c lv_spinner.c lv_roller.c lv_table.c lv_tabview.c lv_tileview.c lv_btn.c lv_calendar.c lv_chart.c lv_canvas.c lv_gauge.c lv_label.c lv_list.c lv_slider.c lv_textarea.c lv_spinbox.c lv_btnmatrix.c lv_cont.c lv_img.c lv_imgbtn.c lv_led.c lv_linemeter.c lv_page.c lv_switch.c lv_win.c lv_objmask.c
    ../../../3rd/littlevgl/lvgl-release-v7/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_12_subpx.c lv_font_montserrat_28_compressed.c lv_font_unscii_8.c lv_font_dejavu_16_persian_hebrew.c
    ../../../3rd/littlevgl/lvgl-release-v7/src/lv_misc/: lv_area.c lv_task.c lv_fs.c lv_anim.c lv_mem.c lv_ll.c lv_color.c lv_txt.c lv_txt_ap.c lv_math.c lv_log.c lv_gc.c lv_utils.c lv_async.c lv_printf.c lv_bidi.c lv_debug.c
    ../../../3rd/littlevgl/lvgl-release-v7/src/lv_themes/: lv_theme.c lv_theme_material.c lv_theme_mono.c lv_theme_empty.c lv_theme_template.c
    ../../../3rd/littlevgl/lvgl-release-v7/src/lv_draw/: lv_draw_mask.c lv_draw_blend.c lv_draw_rect.c lv_draw_label.c lv_draw_line.c lv_draw_img.c lv_draw_arc.c lv_draw_triangle.c lv_img_decoder.c lv_img_cache.c lv_img_buf.c
    ../../../3rd/littlevgl/lvgl-release-v7/src/lv_gpu/: lv_gpu_stm32_dma2d.c
  group fatfs
    ../../../3rd/fatfs/src/: diskio_sdrv.c ff.c ffsystem.c ffunicode.c
  group target
    ../../../target/reference_x9/safety/: target_init.c port.c touch_device.c cam_dev.c
  group platform
    ../../../platform/kunlun/safety/: platform.c debug.c uart.c timer.c interrupt.c reboot.c soc_init.c hpi_qos_init.c scr_init.c domain_config.c
    ../../../platform/kunlun/safety/toolchain/iar/: tcm_init.S
    ../../../platform/kunlun/common/arm/: com_platform.c
  group kernel
    ../../../kernel/lk_wrapper/: lk_event.c lk_mutex.c lk_semaphore.c lk_timers.c lk_thread.c
  group hal
    ../../../hal/audio_hal/audio_manager/src/: am_api.c am.c
    ../../../hal/boardinfo/: boardinfo_common.c boardinfo_hwid_hw.c eeprom.c boardinfo_hwid_usr.c
    ../../../hal/clkgen_hal/sd_clkgen_hal/src/: clkgen_hal.c clkgen_hal_ip_test.c
    ../../../hal/cpu_hal/sd_cpu_hal/src/: boot_ss.c boot_ss_cfg.c
    ../../../hal/crypto_hal/src/: crypto_hal.c
    ../../../hal/crypto_hal/src/pka/: sd_rsa.c sd_ecc.c sd_sm2.c sd_dsa.c sd_ecdsa.c
    ../../../hal/crypto_hal/src/cipher/: sd_aes.c
    ../../../hal/crypto_hal/src/mac/: sd_cmac.c sd_hmac.c
    ../../../hal/crypto_hal/src/hash/: sd_hash.c
    ../../../hal/crypto_hal/src/rng/: sd_rng.c
    ../../../hal/csi_hal/sd_csi_hal/src/: csi_hal.c mipi_csi_hal.c
    ../../../hal/dio_hal/sd_dio_hal/src/: hal_dio.c
    ../../../hal/disp_hal/sd_disp_hal/src/: disp_hal.c
    ../../../hal/dma_hal/sd_dma_hal/src/: dma_hal.c
    ../../../hal/firewall_hal/src/: firewall_hal_weak.c
    ../../../hal/g2dlite_hal/sd_g2dlite_hal/src/: g2dlite_hal.c
    ../../../hal/gpioirq_hal/: gpioirq.c
    ../../../hal/i2c_hal/sd_i2c_hal/src/: i2c_hal.c i2c_hal_ip_test.c
    ../../../hal/interrupt_hal/arm_gic_hal/src/: arm_gic_hal.c
    ../../../hal/mbox_hal/sd_mbox_hal/src/: mbox_hal.c
    ../../../hal/mmc/src/: mmc_hal_weak.c
    ../../../hal/module_helper_hal/src/: module_helper_hal.c
    ../../../hal/module_helper_hal/src/res/: res_clk.c res_rstgen.c
    ../../../hal/module_helper_hal/src/per/: per_disp.c
    ../../../hal/net/: rpmsg_net_rtos.c
    ../../../hal/pll/src/: pll_hal.c
    ../../../hal/pmu_hal/sd_pmu_hal/src/: pmu_hal.c
    ../../../hal/port_hal/sd_port_hal/src/: hal_port.c
    ../../../hal/pvt_hal/src/: pvt_hal.c
    ../../../hal/pwm_hal/sd_pwm_hal/src/: pwm_hal.c
    ../../../hal/res/src/: res.c
    ../../../hal/rstgen_hal/sd_rstgen_hal/src/: rstgen_hal.c
    ../../../hal/scr/src/: scr_hal.c
    ../../../hal/spdif_hal/sd_spdif_hal/src/: spdif_hal_weak.c
    ../../../hal/spi_hal/sd_spi_hal/src/: spi_hal_master_weak.c spi_hal_slave_weak.c
    ../../../hal/spi_nor/src/: spi_nor_hal.c
    ../../../hal/timer_hal/sd_timer_hal/src/: timer_hal.c
    ../../../hal/uart_hal/dw_uart_hal/src/: uart_hal.c
    ../../../hal/vpu_hal/codaj12/src/: vpu_hal.c
    ../../../hal/wdg_hal/sd_wdg_hal/src/: wdg_hal_weak.c wdg_hal_weak_ip_test.c
    ../../../hal/i2s_hal/sd_i2s_hal/2.0/src/: i2s_hal.c
  group framework
    ../../../framework/communication/: ipcc_hal_mb.c ipcc_rpmsg.c ipcc_rpmsg_ns.c ipcc_service.c ipcc_queue.c ipcc_device.c ipcc_rpc.c
    ../../../framework/protocol/: core.c
    ../../../framework/rpbuf/: rpbuf_core.c
    ../../../framework/service/audio/: audio_rpc_svc.c
    ../../../framework/service/backlight/backlight_rtos/: backlight.c
    ../../../framework/service/base/: dcf_common.c dcf_file.c dcf_select.c dcf_notify.c dcf_service.c
    ../../../framework/service/camera/: safe_cs.c
    ../../../framework/service/input/: safe_ts.c touch_driver.c indev_local.c
    ../../../framework/service/rpmsg/: rpmsg_device.c rpmsg_echo.c rpmsg_tty.c rpmsg_channel.c
    ../../../framework/service/sys_diagnosis/: sys_diagnosis.c
    ../../../framework/service/worker/: worker.c
    ../../../framework/test/dcf/: dcf_sample.c test_rpmsg_linux.c test_posix.c
    ../../../framework/service/property/: property.c
    ../../../framework/lib/mem_image/: mem_image.c
  group exdev
    ../../../exdev/am_board/refa04/src/: refa04_path.c
    ../../../exdev/am_codec/ak7738/src/: ak7738.c
    ../../../exdev/am_codec/tca9539/src/: am_tca9539.c
    ../../../exdev/am_codec/tas6424/src/: tas6424.c
    ../../../exdev/am_codec/xf6020/src/: xf6020.c
    ../../../exdev/am_codec/tas5404/src/: am_tas5404.c
    ../../../exdev/display/lv_drivers/display/: sd_disp_drv.c
    ../../../exdev/display/lv_drivers/gpu/: lv_gpu_sdrv_dma2d.c
    ../../../exdev/display/lv_drivers/fs/: fatfs_semidrive.c
    ../../../exdev/display/lv_drivers/input/: lv_port_indev.c
    ../../../exdev/display/lv_drivers/decoder/lodepng/: lodepng.c lv_png.c
    ../../../exdev/display/lv_drivers/decoder/sjpg/: tjpgd.c lv_sjpg.c
    ../../../exdev/display/: lvgl_gui.c sdm_display.c
    ../../../exdev/gpio/src/: tca9539.c tca6408.c
    ../../../exdev/camera/src/: ov5640.c mipi_bridge.c max9286.c ov10640.c max20086.c
    ../../../exdev/lcm/: disp_panels.c
    ../../../exdev/lcm/sn65dsi85/src/: dsi85.c
    ../../../exdev/lcm/ds90ub9xx/src/: ds90ub941as.c ds90ub947.c ds90ub927.c ds90ub9xx_i2c_rw.c
    ../../../exdev/norflash/: mt35x.c
    ../../../exdev/touch/src/: serdes_9xx.c goodix.c
    ../../../exdev/audio_codec/ak7738/: akm_ak7738.c
    ../../../exdev/audio_codec/tas6424/: ti_tas6424.c
    ../../../exdev/lcm/lvds_hsd123_serdes_1920x720_lcd/: lvds_hsd123_serdes_1920x720_lcd.c
  group application
    ../../../application/services/update_monitor/: update_monitor.c
    ../../../application/system/boot_ss/: app_boot_ss.c
    ../../../application/system/kernel_monitor/: km_dump.c km.c
    ../../../application/system/ospi_handover/: ospi_handover.c
    ../../../application/system/pvt/: pvt_print.c
    ../../../application/test/g2dlite/: g2dlite_example.c
    ../../../application/tools/port_helper/: port_helper.c
    ../../../application/tools/sem_monitor/: sem_monitor.c
    ../../../application/early_app/BootAnimation/src/: ba_config.c player_g2d.c decoder_task.c vpu2disp.c animation.c player_task.c audio_task.c ba_replay.c
    ../../../application/early_app/cluster/src/: lv_demo_cluster.c
    ../../../application/early_app/main/src/: early_app.c early_app_cfg.c
  group freertos
    ../../../../../Source/portable/GCC/ARM_CR5/toolchain/iar/: portASM.S
    ../../../../../Source/portable/GCC/ARM_CR5/: cr5_port.c
    ../../../../../Source/portable/MemMang/: heap_4.c
    ../../../../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib
    ../../../lib/apploader/: app.c
    ../../../lib/debug/: lib_debug.c
    ../../../lib/debugcommands/: debugcommands.c
    ../../../lib/heap/: heap_wrapper.c
    ../../../lib/libc/: atoi.c bsearch.c ctype.c errno.c printf.c rand.c strtol.c strtoll.c stdio.c qsort.c eabi.c atexit.c pure_virtual.cpp
    ../../../lib/libc/string/arch/arm/arm/toolchain/iar/: memcpy.S memset.S
    ../../../lib/libc/string/: memchr.c memcmp.c strcat.c strchr.c strcmp.c strcoll.c strcpy.c strdup.c strerror.c strlcat.c strlcpy.c strlen.c strncat.c strncpy.c strncmp.c strnicmp.c strnlen.c strpbrk.c strrchr.c strspn.c strstr.c strtok.c strxfrm.c
    ../../../lib/sdrpc/: sdrpc.c
    ../../../lib/shell/: shell.c
    ../../../lib/storage_device/: storage_device.c storage_dev_mmc.c storage_dev_ospi.c storage_dev_mem.c
    ../../../lib/system_config/: system_configs_parse.c
    ../../../lib/cbuf/: cbuf.c
    ../../../lib/console/: console.c
    ../../../lib/container/: container.c
    ../../../lib/elf/: elf.c
    ../../../lib/io/: io_console.c io.c
    ../../../lib/reboot/: reboot_service.c
    ../../../lib/res_loader/: res_loader.c
    ../../../lib/sdunittest/: all_sdtests.c
    ../../../lib/boot/: boot.c
    ../../../lib/sdcast/: surface_receiver.c
    ../../../hal/audio_hal/audio_manager/lib/: libam_lib.a
    ../../../hal/disp_hal/sd_disp_hal/lib/: libsd_disp.a
    ../../../hal/g2dlite_hal/sd_g2dlite_hal/lib/: libg2dlite.a
    ../../../application/early_app/cluster/../../../lib/sd_graphics/: libsd_graphics.a
  group chipdev
    ../../../chipdev/clkgen/sd_clkgen/src/: clkgen_drv.c clkgen_drv_test.c
    ../../../chipdev/crypto/silex/: sram_conf.c ce.c sx_hash.c sx_cipher.c sx_pke_conf.c sx_rsa_pad.c sx_dma.c sx_rsa.c sx_trng.c sx_ecc_keygen.c sx_ecdsa.c sx_sm2.c sx_dsa.c sx_srp.c sx_eddsa.c sx_pke_funcs.c sx_ecc.c sx_math.c sx_prime.c
    ../../../chipdev/csi/sd_csi/src/: v4l2.c sd_csi.c sd_mipi_csi2.c
    ../../../chipdev/dio/sd_dio/src/: Dio.c
    ../../../chipdev/dma/dw_dma1/: dw_dmac1.c dw_dmac1_mux.c dw_dma1.c
    ../../../chipdev/fuse_ctrl/src/: fuse_ctrl.c
    ../../../chipdev/i2c/dw_i2c/src/: dw_i2c.c dw_i2c_test.c
    ../../../chipdev/interrupt/arm_gic/src/: arm_gic.c
    ../../../chipdev/mailbox/sd_mbox/: mb_controller.c
    ../../../chipdev/pll/src/: pll.c
    ../../../chipdev/pmu/sd_pmu/src/: pmu_drv.c
    ../../../chipdev/port/sd_port/src/: sd_port.c Port_PBcfg.c
    ../../../chipdev/pwm/sd_pwm/src/: pwm_drv.c
    ../../../chipdev/rstgen/sd_rstgen/src/: rstgen_drv.c
    ../../../chipdev/rtc/src/: rtc_drv.c
    ../../../chipdev/scr/: scr.c
    ../../../chipdev/spi_nor/host/: cadence_ospi.c
    ../../../chipdev/timer/sd_timer/src/: timer_drv.c
    ../../../chipdev/uart/dw_uart/src/: uart_drv.c
    ../../../chipdev/vpu/codaj12/src/jpuapi/: jpulog.c jpuapi.c jpuapifunc.c
    ../../../chipdev/vpu/codaj12/src/jdi/: jdi.c mm.c
    ../../../chipdev/func_safety/src/: sem.c eic.c bipc.c
    ../../../chipdev/i2s/cadence_i2s/2.0/src/: sc.c
  group arch
    ../../../arch/arm/arm/toolchain/iar/: start.S asm.S cache-ops.S ops.S exceptions.S usercopy.S
    ../../../arch/arm/arm/: cache.c arm_debug.c faults.c fpu.c mpu.c arch.c
  group top
    ../../../top/: init.c main.c
