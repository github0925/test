# IAR project safety-v9f-ref_ddram.ewp, settings and files
configuration safety-v9f-ref_ddram (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.PreInclude: iar_config.h
  ICCARM.CCIncludePath2: ..\..\..\.\build-safety-v9f-ref; ..\..\..\.\include; ..\..\..\.\include\kernel; ..\..\..\.\include\shared; ..\..\..\.\include\shared\lk; ..\..\..\.\include\uapi; ..\..\..\.\include\uapi\uapi; ..\..\..\3rd\fatfs\src\include; ..\..\..\3rd\rpmsg-lite\include; ..\..\..\application\early_app\include; ..\..\..\application\early_app\main\inc; ..\..\..\application\early_app\main\include; ..\..\..\application\system\boot_ss\include; ..\..\..\application\system\ospi_handover\include; ..\..\..\application\system\pvt\include; ..\..\..\application\test\can\include; ..\..\..\application\test\lin\include; ..\..\..\application\tools\port_helper\include; ..\..\..\arch\arm\arm\include; ..\..\..\arch\arm\include; ..\..\..\chipcfg\generate\v9f\chip\; ..\..\..\chipcfg\generate\v9f\projects\default\; ..\..\..\chipcfg\generate\v9f\projects\default\safety; ..\..\..\chipcfg\generate\v9f\targets\reference_v9\; ..\..\..\chipcfg\generate\v9f\targets\reference_v9\safety; ..\..\..\chipdev\can\flexcan\include; ..\..\..\chipdev\can\include; ..\..\..\chipdev\clkgen\sd_clkgen\inc\; ..\..\..\chipdev\clkgen\sd_clkgen\include; ..\..\..\chipdev\crypto\silex\include; ..\..\..\chipdev\crypto\silex\include\; ..\..\..\chipdev\csi\sd_csi\include; ..\..\..\chipdev\csi\sd_csi\include\; ..\..\..\chipdev\dio\sd_dio\inc\; ..\..\..\chipdev\dio\sd_dio\include; ..\..\..\chipdev\disp\sd_disp\dsi\inc; ..\..\..\chipdev\disp\sd_disp\inc; ..\..\..\chipdev\disp\sd_disp\include; ..\..\..\chipdev\dma\dw_dma1\include; ..\..\..\chipdev\dma\dw_dma1\include\; ..\..\..\chipdev\func_safety\inc\; ..\..\..\chipdev\func_safety\include; ..\..\..\chipdev\fuse_ctrl\inc\; ..\..\..\chipdev\fuse_ctrl\include; ..\..\..\chipdev\i2c\dw_i2c\include; ..\..\..\chipdev\i2c\dw_i2c\include\; ..\..\..\chipdev\i2s\cadence_i2s\..\..\..\hal\audio_hal\common; ..\..\..\chipdev\i2s\cadence_i2s\1.0\inc\; ..\..\..\chipdev\i2s\cadence_i2s\1.0\include; ..\..\..\chipdev\interrupt\arm_gic\inc\; ..\..\..\chipdev\interrupt\arm_gic\include; ..\..\..\chipdev\mailbox\sd_mbox; ..\..\..\chipdev\mailbox\sd_mbox\include; ..\..\..\chipdev\pll\inc; ..\..\..\chipdev\pll\include; ..\..\..\chipdev\pmu\sd_pmu\inc\; ..\..\..\chipdev\pmu\sd_pmu\include; ..\..\..\chipdev\port\sd_port\inc\; ..\..\..\chipdev\port\sd_port\include; ..\..\..\chipdev\rstgen\sd_rstgen\inc\; ..\..\..\chipdev\rstgen\sd_rstgen\include; ..\..\..\chipdev\rtc\inc\; ..\..\..\chipdev\rtc\include; ..\..\..\chipdev\scr\include; ..\..\..\chipdev\spi_nor; ..\..\..\chipdev\spi_nor\device; ..\..\..\chipdev\spi_nor\host; ..\..\..\chipdev\spi_nor\include; ..\..\..\chipdev\timer\sd_timer\inc\; ..\..\..\chipdev\timer\sd_timer\include; ..\..\..\chipdev\uart\dw_uart\inc\; ..\..\..\chipdev\uart\dw_uart\include; ..\..\..\chipdev\vpu\codaj12\inc; ..\..\..\chipdev\vpu\codaj12\inc\jdi; ..\..\..\chipdev\vpu\codaj12\inc\jpuapi; ..\..\..\chipdev\vpu\codaj12\include; ..\..\..\exdev\display\include; ..\..\..\exdev\gpio\include; ..\..\..\exdev\lcm; ..\..\..\exdev\lcm\ds90ub9xx\include; ..\..\..\exdev\lcm\include; ..\..\..\exdev\lcm\lt9611\include; ..\..\..\exdev\lcm\mipi_hsd123_serdes_1920x720_v9_lcd\include; ..\..\..\exdev\lcm\sn65dsi85\include; ..\..\..\exdev\norflash; ..\..\..\exdev\norflash\include; ..\..\..\external\include; ..\..\..\external\include\shared; ..\..\..\external\include\shared\lk; ..\..\..\external\include\uapi; ..\..\..\external\include\uapi\uapi; ..\..\..\framework\audio\core\inc\; ..\..\..\framework\audio\core\include; ..\..\..\framework\communication\include; ..\..\..\framework\lib\mem_image; ..\..\..\framework\lib\mem_image\include; ..\..\..\framework\lib\system; ..\..\..\framework\lib\system\include; ..\..\..\framework\protocol\include; ..\..\..\framework\protocol\include\; ..\..\..\framework\rpbuf\include; ..\..\..\framework\rpbuf\include\; ..\..\..\framework\service\base; ..\..\..\framework\service\base\include; ..\..\..\framework\service\can_proxy\bundle; ..\..\..\framework\service\can_proxy\include; ..\..\..\framework\service\can_proxy\interface; ..\..\..\framework\service\can_proxy\interface\rpmsg; ..\..\..\framework\service\can_proxy\utils; ..\..\..\framework\service\property; ..\..\..\framework\service\property\include; ..\..\..\framework\service\rpmsg\include; ..\..\..\framework\service\samples\include; ..\..\..\framework\service\sys_diagnosis; ..\..\..\framework\service\sys_diagnosis\include; ..\..\..\framework\service\update_monitor\include; ..\..\..\framework\service\worker; ..\..\..\framework\service\worker\include; ..\..\..\framework\test\dcf\include; ..\..\..\hal\boardinfo\; ..\..\..\hal\boardinfo\include; ..\..\..\hal\clkgen_hal\sd_clkgen_hal\inc\; ..\..\..\hal\clkgen_hal\sd_clkgen_hal\include; ..\..\..\hal\cpu_hal\sd_cpu_hal\inc; ..\..\..\hal\cpu_hal\sd_cpu_hal\include; ..\..\..\hal\crypto_hal\inc\; ..\..\..\hal\crypto_hal\include; ..\..\..\hal\csi_hal\sd_csi_hal\inc\; ..\..\..\hal\csi_hal\sd_csi_hal\include; ..\..\..\hal\dio_hal\sd_dio_hal\inc\; ..\..\..\hal\dio_hal\sd_dio_hal\include; ..\..\..\hal\disp_hal\sd_disp_hal\inc; ..\..\..\hal\disp_hal\sd_disp_hal\include; ..\..\..\hal\disp_hal\sd_disp_hal\lib\inc; ..\..\..\hal\dma_hal\sd_dma_hal\inc\; ..\..\..\hal\dma_hal\sd_dma_hal\include; ..\..\..\hal\firewall_hal\inc\; ..\..\..\hal\firewall_hal\include; ..\..\..\hal\gpioirq_hal\include; ..\..\..\hal\gpioirq_hal\include\; ..\..\..\hal\i2c_hal\sd_i2c_hal\inc\; ..\..\..\hal\i2c_hal\sd_i2c_hal\include; ..\..\..\hal\i2s_hal\sd_i2s_hal\1.0\inc\; ..\..\..\hal\i2s_hal\sd_i2s_hal\1.0\include; ..\..\..\hal\i2s_hal\sd_i2s_hal\inc\; ..\..\..\hal\include\; ..\..\..\hal\interrupt_hal\arm_gic_hal\inc\; ..\..\..\hal\interrupt_hal\arm_gic_hal\include; ..\..\..\hal\lin_hal\inc; ..\..\..\hal\lin_hal\include; ..\..\..\hal\mbox_hal\sd_mbox_hal\inc\; ..\..\..\hal\mbox_hal\sd_mbox_hal\include; ..\..\..\hal\mmc\inc\; ..\..\..\hal\mmc\include; ..\..\..\hal\module_helper_hal\inc; ..\..\..\hal\module_helper_hal\include; ..\..\..\hal\net\include; ..\..\..\hal\pll\inc; ..\..\..\hal\pll\include; ..\..\..\hal\pmu_hal\sd_pmu_hal\inc\; ..\..\..\hal\pmu_hal\sd_pmu_hal\include; ..\..\..\hal\port_hal\sd_port_hal\inc\; ..\..\..\hal\port_hal\sd_port_hal\include; ..\..\..\hal\pvt_hal\inc\; ..\..\..\hal\pvt_hal\include; ..\..\..\hal\pwm_hal\sd_pwm_hal\inc\; ..\..\..\hal\pwm_hal\sd_pwm_hal\include; ..\..\..\hal\res\inc; ..\..\..\hal\res\include; ..\..\..\hal\rstgen_hal\sd_rstgen_hal\inc\; ..\..\..\hal\rstgen_hal\sd_rstgen_hal\include; ..\..\..\hal\scr\inc; ..\..\..\hal\scr\include; ..\..\..\hal\spdif_hal\sd_spdif_hal\inc\; ..\..\..\hal\spdif_hal\sd_spdif_hal\include; ..\..\..\hal\spi_hal\sd_spi_hal\inc\; ..\..\..\hal\spi_hal\sd_spi_hal\include; ..\..\..\hal\spi_nor\inc\; ..\..\..\hal\spi_nor\include; ..\..\..\hal\timer_hal\sd_timer_hal\inc\; ..\..\..\hal\timer_hal\sd_timer_hal\include; ..\..\..\hal\uart_hal\dw_uart_hal\inc\; ..\..\..\hal\uart_hal\dw_uart_hal\include; ..\..\..\hal\vpu_hal\codaj12\inc\; ..\..\..\hal\vpu_hal\codaj12\include; ..\..\..\hal\wdg_hal\sd_wdg_hal\inc\; ..\..\..\hal\wdg_hal\sd_wdg_hal\include; ..\..\..\include\include; ..\..\..\include\include\shared; ..\..\..\include\include\shared\lk; ..\..\..\include\include\uapi; ..\..\..\include\include\uapi\uapi; ..\..\..\kernel\include; ..\..\..\kernel\lk_wrapper\include; ..\..\..\lib\apploader\include; ..\..\..\lib\boot\include; ..\..\..\lib\cbuf\include; ..\..\..\lib\cbuf\include\lib; ..\..\..\lib\console\include; ..\..\..\lib\container\inc; ..\..\..\lib\container\include; ..\..\..\lib\debug\include; ..\..\..\lib\debugcommands\include; ..\..\..\lib\elf\include; ..\..\..\lib\heap\; ..\..\..\lib\heap\include; ..\..\..\lib\io\include; ..\..\..\lib\libc\include; ..\..\..\lib\reboot; ..\..\..\lib\reboot\include; ..\..\..\lib\res_loader; ..\..\..\lib\res_loader\include; ..\..\..\lib\sdrpc; ..\..\..\lib\sdrpc\include; ..\..\..\lib\sdunittest\include; ..\..\..\lib\shell\include; ..\..\..\lib\storage_device\include; ..\..\..\lib\system_config\; ..\..\..\lib\system_config\include; ..\..\..\platform\kunlun; ..\..\..\platform\kunlun\..\..\chipcfg\generate\v9f\; ..\..\..\platform\kunlun\common; ..\..\..\platform\kunlun\common\include; ..\..\..\platform\kunlun\safety\; ..\..\..\platform\kunlun\safety\include; ..\..\..\target\reference_v9\safety\; ..\..\..\target\reference_v9\safety\include; ..\..\..\top\include; ..\..\..\lib\boot\include; ..\..\..\.; ..\..\..\..\freertos\FreeRTOS\Source\include; ..\..\..\..\freertos\FreeRTOS\Source\portable\GCC\ARM_CR5; ..\..\..\hal\disp_hal\sd_disp_hal\lib\inc; ..\..\..\3rd\rpmsg-lite\include; ..\..\..\framework\communication\include; ..\..\..\..\..\Source\include; ..\..\..\..\..\Source\portable\GCC\ARM_CR5; ..\..\..\.; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ASSEMBLY; __ICCARM__
  AARM.AUserIncludes: ..\..\..\.\build-safety-v9f-ref; ..\..\..\.\include; ..\..\..\.\include\kernel; ..\..\..\.\include\shared; ..\..\..\.\include\shared\lk; ..\..\..\.\include\uapi; ..\..\..\.\include\uapi\uapi; ..\..\..\3rd\fatfs\src\include; ..\..\..\3rd\rpmsg-lite\include; ..\..\..\application\early_app\include; ..\..\..\application\early_app\main\inc; ..\..\..\application\early_app\main\include; ..\..\..\application\system\boot_ss\include; ..\..\..\application\system\ospi_handover\include; ..\..\..\application\system\pvt\include; ..\..\..\application\test\can\include; ..\..\..\application\test\lin\include; ..\..\..\application\tools\port_helper\include; ..\..\..\arch\arm\arm\include; ..\..\..\arch\arm\include; ..\..\..\chipcfg\generate\v9f\chip\; ..\..\..\chipcfg\generate\v9f\projects\default\; ..\..\..\chipcfg\generate\v9f\projects\default\safety; ..\..\..\chipcfg\generate\v9f\targets\reference_v9\; ..\..\..\chipcfg\generate\v9f\targets\reference_v9\safety; ..\..\..\chipdev\can\flexcan\include; ..\..\..\chipdev\can\include; ..\..\..\chipdev\clkgen\sd_clkgen\inc\; ..\..\..\chipdev\clkgen\sd_clkgen\include; ..\..\..\chipdev\crypto\silex\include; ..\..\..\chipdev\crypto\silex\include\; ..\..\..\chipdev\csi\sd_csi\include; ..\..\..\chipdev\csi\sd_csi\include\; ..\..\..\chipdev\dio\sd_dio\inc\; ..\..\..\chipdev\dio\sd_dio\include; ..\..\..\chipdev\disp\sd_disp\dsi\inc; ..\..\..\chipdev\disp\sd_disp\inc; ..\..\..\chipdev\disp\sd_disp\include; ..\..\..\chipdev\dma\dw_dma1\include; ..\..\..\chipdev\dma\dw_dma1\include\; ..\..\..\chipdev\func_safety\inc\; ..\..\..\chipdev\func_safety\include; ..\..\..\chipdev\fuse_ctrl\inc\; ..\..\..\chipdev\fuse_ctrl\include; ..\..\..\chipdev\i2c\dw_i2c\include; ..\..\..\chipdev\i2c\dw_i2c\include\; ..\..\..\chipdev\i2s\cadence_i2s\..\..\..\hal\audio_hal\common; ..\..\..\chipdev\i2s\cadence_i2s\1.0\inc\; ..\..\..\chipdev\i2s\cadence_i2s\1.0\include; ..\..\..\chipdev\interrupt\arm_gic\inc\; ..\..\..\chipdev\interrupt\arm_gic\include; ..\..\..\chipdev\mailbox\sd_mbox; ..\..\..\chipdev\mailbox\sd_mbox\include; ..\..\..\chipdev\pll\inc; ..\..\..\chipdev\pll\include; ..\..\..\chipdev\pmu\sd_pmu\inc\; ..\..\..\chipdev\pmu\sd_pmu\include; ..\..\..\chipdev\port\sd_port\inc\; ..\..\..\chipdev\port\sd_port\include; ..\..\..\chipdev\rstgen\sd_rstgen\inc\; ..\..\..\chipdev\rstgen\sd_rstgen\include; ..\..\..\chipdev\rtc\inc\; ..\..\..\chipdev\rtc\include; ..\..\..\chipdev\scr\include; ..\..\..\chipdev\spi_nor; ..\..\..\chipdev\spi_nor\device; ..\..\..\chipdev\spi_nor\host; ..\..\..\chipdev\spi_nor\include; ..\..\..\chipdev\timer\sd_timer\inc\; ..\..\..\chipdev\timer\sd_timer\include; ..\..\..\chipdev\uart\dw_uart\inc\; ..\..\..\chipdev\uart\dw_uart\include; ..\..\..\chipdev\vpu\codaj12\inc; ..\..\..\chipdev\vpu\codaj12\inc\jdi; ..\..\..\chipdev\vpu\codaj12\inc\jpuapi; ..\..\..\chipdev\vpu\codaj12\include; ..\..\..\exdev\display\include; ..\..\..\exdev\gpio\include; ..\..\..\exdev\lcm; ..\..\..\exdev\lcm\ds90ub9xx\include; ..\..\..\exdev\lcm\include; ..\..\..\exdev\lcm\lt9611\include; ..\..\..\exdev\lcm\mipi_hsd123_serdes_1920x720_v9_lcd\include; ..\..\..\exdev\lcm\sn65dsi85\include; ..\..\..\exdev\norflash; ..\..\..\exdev\norflash\include; ..\..\..\external\include; ..\..\..\external\include\shared; ..\..\..\external\include\shared\lk; ..\..\..\external\include\uapi; ..\..\..\external\include\uapi\uapi; ..\..\..\framework\audio\core\inc\; ..\..\..\framework\audio\core\include; ..\..\..\framework\communication\include; ..\..\..\framework\lib\mem_image; ..\..\..\framework\lib\mem_image\include; ..\..\..\framework\lib\system; ..\..\..\framework\lib\system\include; ..\..\..\framework\protocol\include; ..\..\..\framework\protocol\include\; ..\..\..\framework\rpbuf\include; ..\..\..\framework\rpbuf\include\; ..\..\..\framework\service\base; ..\..\..\framework\service\base\include; ..\..\..\framework\service\can_proxy\bundle; ..\..\..\framework\service\can_proxy\include; ..\..\..\framework\service\can_proxy\interface; ..\..\..\framework\service\can_proxy\interface\rpmsg; ..\..\..\framework\service\can_proxy\utils; ..\..\..\framework\service\property; ..\..\..\framework\service\property\include; ..\..\..\framework\service\rpmsg\include; ..\..\..\framework\service\samples\include; ..\..\..\framework\service\sys_diagnosis; ..\..\..\framework\service\sys_diagnosis\include; ..\..\..\framework\service\update_monitor\include; ..\..\..\framework\service\worker; ..\..\..\framework\service\worker\include; ..\..\..\framework\test\dcf\include; ..\..\..\hal\boardinfo\; ..\..\..\hal\boardinfo\include; ..\..\..\hal\clkgen_hal\sd_clkgen_hal\inc\; ..\..\..\hal\clkgen_hal\sd_clkgen_hal\include; ..\..\..\hal\cpu_hal\sd_cpu_hal\inc; ..\..\..\hal\cpu_hal\sd_cpu_hal\include; ..\..\..\hal\crypto_hal\inc\; ..\..\..\hal\crypto_hal\include; ..\..\..\hal\csi_hal\sd_csi_hal\inc\; ..\..\..\hal\csi_hal\sd_csi_hal\include; ..\..\..\hal\dio_hal\sd_dio_hal\inc\; ..\..\..\hal\dio_hal\sd_dio_hal\include; ..\..\..\hal\disp_hal\sd_disp_hal\inc; ..\..\..\hal\disp_hal\sd_disp_hal\include; ..\..\..\hal\disp_hal\sd_disp_hal\lib\inc; ..\..\..\hal\dma_hal\sd_dma_hal\inc\; ..\..\..\hal\dma_hal\sd_dma_hal\include; ..\..\..\hal\firewall_hal\inc\; ..\..\..\hal\firewall_hal\include; ..\..\..\hal\gpioirq_hal\include; ..\..\..\hal\gpioirq_hal\include\; ..\..\..\hal\i2c_hal\sd_i2c_hal\inc\; ..\..\..\hal\i2c_hal\sd_i2c_hal\include; ..\..\..\hal\i2s_hal\sd_i2s_hal\1.0\inc\; ..\..\..\hal\i2s_hal\sd_i2s_hal\1.0\include; ..\..\..\hal\i2s_hal\sd_i2s_hal\inc\; ..\..\..\hal\include\; ..\..\..\hal\interrupt_hal\arm_gic_hal\inc\; ..\..\..\hal\interrupt_hal\arm_gic_hal\include; ..\..\..\hal\lin_hal\inc; ..\..\..\hal\lin_hal\include; ..\..\..\hal\mbox_hal\sd_mbox_hal\inc\; ..\..\..\hal\mbox_hal\sd_mbox_hal\include; ..\..\..\hal\mmc\inc\; ..\..\..\hal\mmc\include; ..\..\..\hal\module_helper_hal\inc; ..\..\..\hal\module_helper_hal\include; ..\..\..\hal\net\include; ..\..\..\hal\pll\inc; ..\..\..\hal\pll\include; ..\..\..\hal\pmu_hal\sd_pmu_hal\inc\; ..\..\..\hal\pmu_hal\sd_pmu_hal\include; ..\..\..\hal\port_hal\sd_port_hal\inc\; ..\..\..\hal\port_hal\sd_port_hal\include; ..\..\..\hal\pvt_hal\inc\; ..\..\..\hal\pvt_hal\include; ..\..\..\hal\pwm_hal\sd_pwm_hal\inc\; ..\..\..\hal\pwm_hal\sd_pwm_hal\include; ..\..\..\hal\res\inc; ..\..\..\hal\res\include; ..\..\..\hal\rstgen_hal\sd_rstgen_hal\inc\; ..\..\..\hal\rstgen_hal\sd_rstgen_hal\include; ..\..\..\hal\scr\inc; ..\..\..\hal\scr\include; ..\..\..\hal\spdif_hal\sd_spdif_hal\inc\; ..\..\..\hal\spdif_hal\sd_spdif_hal\include; ..\..\..\hal\spi_hal\sd_spi_hal\inc\; ..\..\..\hal\spi_hal\sd_spi_hal\include; ..\..\..\hal\spi_nor\inc\; ..\..\..\hal\spi_nor\include; ..\..\..\hal\timer_hal\sd_timer_hal\inc\; ..\..\..\hal\timer_hal\sd_timer_hal\include; ..\..\..\hal\uart_hal\dw_uart_hal\inc\; ..\..\..\hal\uart_hal\dw_uart_hal\include; ..\..\..\hal\vpu_hal\codaj12\inc\; ..\..\..\hal\vpu_hal\codaj12\include; ..\..\..\hal\wdg_hal\sd_wdg_hal\inc\; ..\..\..\hal\wdg_hal\sd_wdg_hal\include; ..\..\..\include\include; ..\..\..\include\include\shared; ..\..\..\include\include\shared\lk; ..\..\..\include\include\uapi; ..\..\..\include\include\uapi\uapi; ..\..\..\kernel\include; ..\..\..\kernel\lk_wrapper\include; ..\..\..\lib\apploader\include; ..\..\..\lib\boot\include; ..\..\..\lib\cbuf\include; ..\..\..\lib\cbuf\include\lib; ..\..\..\lib\console\include; ..\..\..\lib\container\inc; ..\..\..\lib\container\include; ..\..\..\lib\debug\include; ..\..\..\lib\debugcommands\include; ..\..\..\lib\elf\include; ..\..\..\lib\heap\; ..\..\..\lib\heap\include; ..\..\..\lib\io\include; ..\..\..\lib\libc\include; ..\..\..\lib\reboot; ..\..\..\lib\reboot\include; ..\..\..\lib\res_loader; ..\..\..\lib\res_loader\include; ..\..\..\lib\sdrpc; ..\..\..\lib\sdrpc\include; ..\..\..\lib\sdunittest\include; ..\..\..\lib\shell\include; ..\..\..\lib\storage_device\include; ..\..\..\lib\system_config\; ..\..\..\lib\system_config\include; ..\..\..\platform\kunlun; ..\..\..\platform\kunlun\..\..\chipcfg\generate\v9f\; ..\..\..\platform\kunlun\common; ..\..\..\platform\kunlun\common\include; ..\..\..\platform\kunlun\safety\; ..\..\..\platform\kunlun\safety\include; ..\..\..\target\reference_v9\safety\; ..\..\..\target\reference_v9\safety\include; ..\..\..\top\include; ..\..\..\lib\boot\include; ..\..\..\.; ..\..\..\..\freertos\FreeRTOS\Source\include; ..\..\..\..\freertos\FreeRTOS\Source\portable\GCC\ARM_CR5; ..\..\..\hal\disp_hal\sd_disp_hal\lib\inc; ..\..\..\3rd\rpmsg-lite\include; ..\..\..\framework\communication\include; ..\..\..\..\FreeRTOS\Source\include; ..\..\..\..\FreeRTOS\Source\portable\GCC\ARM_CR5; ..\..\..\.; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: safety-v9f-ref.bin
  ILINK.IlinkOutputFile: safety-v9f-ref.out
  ILINK.IlinkIcfFile: ..\..\..\target\reference_v9\safety\IAR\ddr.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\hal/disp_hal/sd_disp_hal/lib/libdisp_link.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group rpmsg-lite
    ../../../3rd/rpmsg-lite/: llist.c rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c virtqueue.c
    ../../../3rd/rpmsg-lite/porting/: rpmsg_env_lk.c rpmsg_platform.c
  group fatfs
    ../../../3rd/fatfs/src/: diskio_sdrv.c ff.c ffsystem.c ffunicode.c
  group target
    ../../../target/reference_v9/safety/: target_init.c port.c
  group platform
    ../../../platform/kunlun/safety/: platform.c debug.c uart.c timer.c interrupt.c reboot.c soc_init.c hpi_qos_init.c scr_init.c domain_config.c
    ../../../platform/kunlun/safety/toolchain/iar/: tcm_init.S
    ../../../platform/kunlun/common/arm/: com_platform.c
  group kernel
    ../../../kernel/lk_wrapper/: lk_event.c lk_mutex.c lk_semaphore.c lk_timers.c lk_thread.c
  group hal
    ../../../hal/boardinfo/: boardinfo_common.c boardinfo_hwid_hw.c boardinfo_hwid_usr.c
    ../../../hal/clkgen_hal/sd_clkgen_hal/src/: clkgen_hal.c clkgen_hal_ip_test.c
    ../../../hal/cpu_hal/sd_cpu_hal/src/: boot_ss.c boot_ss_cfg.c
    ../../../hal/crypto_hal/src/: crypto_hal.c
    ../../../hal/crypto_hal/src/pka/: sd_rsa.c sd_ecc.c sd_sm2.c sd_dsa.c sd_ecdsa.c
    ../../../hal/crypto_hal/src/cipher/: sd_aes.c
    ../../../hal/crypto_hal/src/mac/: sd_cmac.c sd_hmac.c
    ../../../hal/crypto_hal/src/hash/: sd_hash.c
    ../../../hal/crypto_hal/src/rng/: sd_rng.c
    ../../../hal/csi_hal/sd_csi_hal/src/: csi_hal.c mipi_csi_hal.c
    ../../../hal/dio_hal/sd_dio_hal/src/: hal_dio.c
    ../../../hal/disp_hal/sd_disp_hal/src/: disp_hal.c
    ../../../hal/dma_hal/sd_dma_hal/src/: dma_hal.c
    ../../../hal/firewall_hal/src/: firewall_hal_weak.c
    ../../../hal/gpioirq_hal/: gpioirq_weak.c
    ../../../hal/i2c_hal/sd_i2c_hal/src/: i2c_hal.c i2c_hal_ip_test.c
    ../../../hal/interrupt_hal/arm_gic_hal/src/: arm_gic_hal.c
    ../../../hal/lin_hal/: Lin.c Lin_PBCfg.c
    ../../../hal/mbox_hal/sd_mbox_hal/src/: mbox_hal.c
    ../../../hal/mmc/src/: mmc_hal_weak.c
    ../../../hal/module_helper_hal/src/: module_helper_hal.c
    ../../../hal/module_helper_hal/src/res/: res_clk.c res_rstgen.c
    ../../../hal/module_helper_hal/src/per/: per_disp.c
    ../../../hal/net/: rpmsg_net_rtos.c
    ../../../hal/pll/src/: pll_hal.c
    ../../../hal/pmu_hal/sd_pmu_hal/src/: pmu_hal.c
    ../../../hal/port_hal/sd_port_hal/src/: hal_port.c
    ../../../hal/pvt_hal/src/: pvt_hal.c
    ../../../hal/pwm_hal/sd_pwm_hal/src/: pwm_hal_weak.c
    ../../../hal/res/src/: res.c
    ../../../hal/rstgen_hal/sd_rstgen_hal/src/: rstgen_hal.c
    ../../../hal/scr/src/: scr_hal.c
    ../../../hal/spdif_hal/sd_spdif_hal/src/: spdif_hal_weak.c
    ../../../hal/spi_hal/sd_spi_hal/src/: spi_hal_master_weak.c spi_hal_slave_weak.c
    ../../../hal/spi_nor/src/: spi_nor_hal.c
    ../../../hal/timer_hal/sd_timer_hal/src/: timer_hal.c
    ../../../hal/uart_hal/dw_uart_hal/src/: uart_hal.c
    ../../../hal/vpu_hal/codaj12/src/: vpu_hal.c
    ../../../hal/wdg_hal/sd_wdg_hal/src/: wdg_hal_weak.c wdg_hal_weak_ip_test.c
    ../../../hal/i2s_hal/sd_i2s_hal/1.0/src/: i2s_hal.c
  group framework
    ../../../framework/audio/core/src/: sd_audio.c
    ../../../framework/communication/: ipcc_hal_mb.c ipcc_rpmsg.c ipcc_rpmsg_ns.c ipcc_service.c ipcc_queue.c ipcc_device.c ipcc_rpc.c
    ../../../framework/lib/system/: sys_cnt.c
    ../../../framework/protocol/: core.c
    ../../../framework/rpbuf/: rpbuf_core.c
    ../../../framework/service/base/: dcf_common.c dcf_file.c dcf_select.c dcf_notify.c dcf_service.c
    ../../../framework/service/can_proxy/: can_proxy.c
    ../../../framework/service/can_proxy/bundle/: can_proxy_bundle.c
    ../../../framework/service/can_proxy/interface/: can_proxy_if.c
    ../../../framework/service/can_proxy/interface/can/: can_port.c
    ../../../framework/service/can_proxy/interface/rpmsg/: rpmsg_port.c
    ../../../framework/service/can_proxy/utils/: can_proxy_buffer.c can_proxy_os_port.c
    ../../../framework/service/rpmsg/: rpmsg_device.c rpmsg_echo.c rpmsg_tty.c rpmsg_channel.c
    ../../../framework/service/samples/: samples_main.c
    ../../../framework/service/sys_diagnosis/: sys_diagnosis.c
    ../../../framework/service/update_monitor/: update_monitor.c
    ../../../framework/service/worker/: worker.c
    ../../../framework/test/dcf/: dcf_sample.c test_rpmsg_linux.c
    ../../../framework/service/property/: property.c
    ../../../framework/lib/mem_image/: mem_image.c
  group exdev
    ../../../exdev/display/: sdm_display.c
    ../../../exdev/lcm/: disp_panels.c
    ../../../exdev/lcm/sn65dsi85/src/: dsi85.c
    ../../../exdev/lcm/ds90ub9xx/src/: ds90ub941as.c ds90ub947.c ds90ub927.c ds90ub9xx_i2c_rw.c
    ../../../exdev/lcm/lt9611/src/: lt9611.c lt9611_i2c.c
    ../../../exdev/norflash/: mt35x.c
    ../../../exdev/gpio/src/: tca9539.c
    ../../../exdev/lcm/mipi_hsd123_serdes_1920x720_v9_lcd/: mipi_hsd123_serdes_1920x720_v9_lcd.c
  group application
    ../../../application/system/boot_ss/: app_boot_ss.c
    ../../../application/system/ospi_handover/: ospi_handover.c
    ../../../application/system/pvt/: pvt_print.c
    ../../../application/test/can/: cmd_can.c
    ../../../application/test/lin/: cmd_lin.c
    ../../../application/tools/port_helper/: port_helper.c
    ../../../application/early_app/main/src/: early_app.c early_app_cfg.c
  group freertos
    ../../../../../Source/portable/GCC/ARM_CR5/toolchain/iar/: portASM.S
    ../../../../../Source/portable/GCC/ARM_CR5/: cr5_port.c
    ../../../../../Source/portable/MemMang/: heap_4.c
    ../../../../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib
    ../../../lib/apploader/: app.c
    ../../../lib/debug/: lib_debug.c
    ../../../lib/debugcommands/: debugcommands.c
    ../../../lib/heap/: heap_wrapper.c
    ../../../lib/libc/: atoi.c bsearch.c ctype.c errno.c printf.c rand.c strtol.c strtoll.c stdio.c qsort.c eabi.c atexit.c pure_virtual.cpp
    ../../../lib/libc/string/arch/arm/arm/toolchain/iar/: memcpy.S memset.S
    ../../../lib/libc/string/: memchr.c memcmp.c strcat.c strchr.c strcmp.c strcoll.c strcpy.c strdup.c strerror.c strlcat.c strlcpy.c strlen.c strncat.c strncpy.c strncmp.c strnicmp.c strnlen.c strpbrk.c strrchr.c strspn.c strstr.c strtok.c strxfrm.c
    ../../../lib/sdrpc/: sdrpc.c
    ../../../lib/shell/: shell.c
    ../../../lib/storage_device/: storage_device.c storage_dev_mmc.c storage_dev_ospi.c storage_dev_mem.c
    ../../../lib/system_config/: system_configs_parse.c
    ../../../lib/cbuf/: cbuf.c
    ../../../lib/console/: console.c
    ../../../lib/container/: container.c
    ../../../lib/elf/: elf.c
    ../../../lib/io/: io_console.c io.c
    ../../../lib/reboot/: reboot_service.c
    ../../../lib/res_loader/: res_loader.c
    ../../../lib/sdunittest/: all_sdtests.c
    ../../../lib/boot/: boot.c
    ../../../chipdev/disp/sd_disp/libs/: libsd_disp.a
  group chipdev
    ../../../chipdev/can/flexcan/: Can.c flexcan.c can_cfg.c
    ../../../chipdev/clkgen/sd_clkgen/src/: clkgen_drv.c clkgen_drv_test.c
    ../../../chipdev/crypto/silex/: sram_conf.c ce.c sx_hash.c sx_cipher.c sx_pke_conf.c sx_rsa_pad.c sx_dma.c sx_rsa.c sx_trng.c sx_ecc_keygen.c sx_ecdsa.c sx_sm2.c sx_dsa.c sx_srp.c sx_eddsa.c sx_pke_funcs.c sx_ecc.c sx_math.c sx_prime.c
    ../../../chipdev/csi/sd_csi/src/: v4l2.c sd_csi.c sd_mipi_csi2.c
    ../../../chipdev/dio/sd_dio/src/: Dio.c
    ../../../chipdev/disp/sd_disp/dsi/: dwc_mipi_dsi_host.c disp_dsi_api.c disp_dsi.c
    ../../../chipdev/disp/sd_disp/core/: disp_drv.c disp_interface.c disp_panel.c
    ../../../chipdev/dma/dw_dma1/: dw_dmac1.c dw_dmac1_mux.c dw_dma1.c
    ../../../chipdev/fuse_ctrl/src/: fuse_ctrl.c
    ../../../chipdev/i2c/dw_i2c/src/: dw_i2c.c dw_i2c_test.c
    ../../../chipdev/interrupt/arm_gic/src/: arm_gic.c
    ../../../chipdev/mailbox/sd_mbox/: mb_controller.c
    ../../../chipdev/pll/src/: pll.c
    ../../../chipdev/pmu/sd_pmu/src/: pmu_drv.c
    ../../../chipdev/port/sd_port/src/: sd_port.c Port_PBcfg.c
    ../../../chipdev/rstgen/sd_rstgen/src/: rstgen_drv.c
    ../../../chipdev/rtc/src/: rtc_drv.c
    ../../../chipdev/scr/: scr.c
    ../../../chipdev/spi_nor/host/: cadence_ospi.c
    ../../../chipdev/timer/sd_timer/src/: timer_drv.c
    ../../../chipdev/uart/dw_uart/src/: uart_drv.c
    ../../../chipdev/vpu/codaj12/src/jpuapi/: jpulog.c jpuapi.c jpuapifunc.c
    ../../../chipdev/vpu/codaj12/src/jdi/: jdi.c mm.c
    ../../../chipdev/func_safety/src/: sem.c eic.c bipc.c
    ../../../chipdev/i2s/cadence_i2s/1.0/src/: mc.c sc.c
  group arch
    ../../../arch/arm/arm/toolchain/iar/: start.S asm.S cache-ops.S ops.S exceptions.S usercopy.S
    ../../../arch/arm/arm/: cache.c arm_debug.c faults.c fpu.c mpu.c arch.c
  group top
    ../../../top/: init.c main.c
