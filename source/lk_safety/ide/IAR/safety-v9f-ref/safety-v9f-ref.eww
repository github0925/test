<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/safety-v9f-ref_ddram.ewp</path>
  </project>
</workspace>
